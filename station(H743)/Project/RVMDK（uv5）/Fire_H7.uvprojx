# Keil uVision project Fire_H7.uvprojx, settings and files
target Fire_H7 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Fire_H7 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32H7xx\Include;..\..\Libraries\STM32H7xx_HAL_Driver\Inc;..\..\User;..\..\GUI\lvgl;..\..\GUI\lvgl_port;..\..\GUI_APP\custom;..\..\GUI_APP\generated;..\..\GUI_APP\generated\guider_customer_fonts;..\..\User\tim
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h743xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group STM32H7xx_HAL_Driver
    ../../Libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_comp.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hash.c stm32h7xx_hal_hash_ex.c stm32h7xx_hal_hcd.c stm32h7xx_hal_hrtim.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_i2s.c stm32h7xx_hal_i2s_ex.c stm32h7xx_hal_irda.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_lptim.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_mdios.c stm32h7xx_hal_mdma.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_nand.c stm32h7xx_hal_nor.c stm32h7xx_hal_opamp.c stm32h7xx_hal_opamp_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_smartcard.c stm32h7xx_hal_smartcard_ex.c stm32h7xx_hal_smbus.c stm32h7xx_hal_spdifrx.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_swpmi.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_wwdg.c stm32h7xx_ll_fmc.c
  group USER
    ../../User/: main.c stm32h7xx_it.c
    ../../User/led/: bsp_led.c
    ../../User/usart/: bsp_usart.c
    ../../User/sdram/: bsp_sdram.c
    ../../User/lcd/: bsp_lcd.c
    ../../User/touch/: bsp_i2c_touch.c gt9xx.c palette.c
    ../../User/flash/: bsp_qspi_flash.c
    ../../User/delay/: core_delay.c
    ../../User/fonts/: resource_port.c
    ../../User/tim/: tim.c
  group DOC
    ../../: 必读说明.txt
  group GUI/lvgl
    ../../GUI/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../../GUI/lvgl/src/draw/arm2d/: lv_gpu_arm2d.c
    ../../GUI/lvgl/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../../GUI/lvgl/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ../../GUI/lvgl/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ../../GUI/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../../GUI/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../../GUI/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../../GUI/lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../../GUI/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../GUI/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../../GUI/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../../GUI/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../../GUI/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../../GUI/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../../GUI/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../../GUI/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../../GUI/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../../GUI/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../../GUI/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../../GUI/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../../GUI/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../../GUI/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../../GUI/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../../GUI/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../../GUI/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../../GUI/lvgl/src/extra/others/msg/: lv_msg.c
    ../../GUI/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../../GUI/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../../GUI/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../../GUI/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../../GUI/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../../GUI/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../GUI/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../../GUI/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../GUI/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../GUI/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../GUI/lvgl/src/extra/widgets/led/: lv_led.c
    ../../GUI/lvgl/src/extra/widgets/list/: lv_list.c
    ../../GUI/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../../GUI/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../GUI/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../../GUI/lvgl/src/extra/widgets/span/: lv_span.c
    ../../GUI/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../GUI/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../../GUI/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../../GUI/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../../GUI/lvgl/src/extra/widgets/win/: lv_win.c
    ../../GUI/lvgl/src/extra/: lv_extra.c
    ../../GUI/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../../GUI/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../../GUI/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../../GUI/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group GUI/lvgl_port
    ../../GUI/lvgl_port/porting/: lv_port_disp.c lv_port_fs.c lv_port_indev.c
  group GUI_APP
    ../../GUI_APP/custom/: custom.c
    ../../GUI_APP/generated/: events_init.c gui_guider.c widgets_init.c setup_scr_screen.c
    ../../GUI_APP/generated/guider_customer_fonts/: guider_customer_fonts.h
    ../../GUI_APP/generated/guider_fonts/: lv_font_montserratMedium_16.c lv_font_montserratMedium_20.c lv_font_montserratMedium_12.c
    ../../GUI_APP/generated/images/: _dwed_alpha_388x308.c
software components: Compiler:I/O:STDERR 1.2.0
